SUMMARY = "Create voluptuous schemas"
HOMEPAGE = "https://github.com/alecthomas/voluptuous"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://COPYING;md5=9855ba150f2edb00d8e7a41554896ffb"

SRC_URI[sha256sum] = "e8d31c20601d6773cb14d4c0f42aee29c6821bbd1018039aac7ac5605b489723"

PYPI_PACKAGE = "voluptuous"
inherit python_setuptools_build_meta pypi

