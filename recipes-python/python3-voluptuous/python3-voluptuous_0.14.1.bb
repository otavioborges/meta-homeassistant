SUMMARY = "Python data validation library"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://README.md;md5=314adee0e124a4ed89dcf418232089a2"

SRC_URI[sha256sum] = "7b6e5f7553ce02461cce17fedb0e3603195496eb260ece9aca86cc4cc6625218"

PYPI_PACKAGE = "voluptuous"

inherit pypi setuptools3
