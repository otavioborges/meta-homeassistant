SUMMARY = "Calculations for the position of the sun and moon."
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=86d3f3a95c324c9479bd8986968f4327"

SRC_URI[sha256sum] = "9b7c3b412e9e69d172cfb24be0e6addcc9f1bd01a28db8bebe66d75ccc533d88"

PYPI_PACKAGE = "astral"

inherit pypi setuptools3
