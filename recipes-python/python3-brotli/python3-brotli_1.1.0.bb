SUMMARY = "Python bindings for the Brotli compression library"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=941ee9cd1609382f946352712a319b4b"

SRC_URI[sha256sum] = "81de08ac11bcb85841e440c13611c00b67d3bf82698314928d0b676362546724"

PYPI_PACKAGE = "Brotli"

inherit pypi setuptools3
