SUMMARY = "GitPython is a Python library used to interact with Git repositories"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=5279a7ab369ba336989dcf2a107e5c8e"

SRC_URI[sha256sum] = "ed66e624884f76df22c8e16066d567aaa5a37d5b5fa19db2c6df6f7156db9048"

PYPI_PACKAGE = "GitPython"

inherit pypi setuptools3
