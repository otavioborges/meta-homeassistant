SUMMARY = "A Python slugify application that also handles Unicode"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=7946d011d653bfcfbb24480377867128"

SRC_URI[sha256sum] = "ce0d46ddb668b3be82f4ed5e503dbc33dd815d83e2eb6824211310d3fb172a27"

PYPI_PACKAGE = "python-slugify"

inherit pypi python_setuptools_build_meta setuptools3
