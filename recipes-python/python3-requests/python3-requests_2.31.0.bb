SUMMARY = "Python HTTP for Humans."
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=34400b68072d710fecd0a2940a0d1658"

SRC_URI[sha256sum] = "942c5a758f98d790eaed1a29cb6eefc7ffb0d1cf7af05c3d2791656dbd6ad1e1"

PYPI_PACKAGE = "requests"

inherit pypi setuptools3
