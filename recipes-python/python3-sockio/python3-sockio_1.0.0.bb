SUMMARY = "GitPython is a Python library used to interact with Git repositories"
HOMEPAGE = "https://github.com/gitpython-developers/GitPython"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=0b4dda8edb09eec767aaded3cbf8f6b1"

SRC_URI[sha256sum] = "f88beb3da5b5c38b9890469de67d0cb0f9d494b78b106ca1845f96c10b91c4ac"

PYPI_PACKAGE = "socksio"
inherit python_setuptools_build_meta pypi

