SUMMARY = "Atomic file writes."
HOMEPAGE = "https://github.com/untitaker/python-atomicwrites"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=91cc36cfafeefb7863673bcfcb1d4da4"

SRC_URI[sha256sum] = "256a672106f16745445228d966240b77b55f46a096d20305901a57aa5d1f4c2f"

PYPI_PACKAGE = "atomicwrites-homeassistant"
inherit python_setuptools_build_meta pypi

