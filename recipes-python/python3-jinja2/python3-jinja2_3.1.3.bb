SUMMARY = "A very fast and expressive template engine."
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE.rst;md5=5dc88300786f1c214c1e9827a5229462"

SRC_URI[sha256sum] = "ac8bd6544d4bb2c9792bf3a159e80bba8fda7f07e81bc3aed565432d5925ba90"

PYPI_PACKAGE = "Jinja2"

inherit pypi setuptools3
