SUMMARY = "Yet another "
HOMEPAGE = "https://github.com/gitpython-developers/GitPython"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=7b6b095fe2a2e2b66cb08d295b605789"

SRC_URI[sha256sum] = "12af2c55b419521e33d5fb21bd022df0b5eb267c3e178f1d374a63a2a6bdccd0"

PYPI_PACKAGE_EXT = "zip"
PYPI_PACKAGE = "debugpy"
inherit python_setuptools_build_meta pypi

