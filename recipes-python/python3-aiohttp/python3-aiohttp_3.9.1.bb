SUMMARY = "Async http client/server framework (asyncio)"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=748073912af33aa59430d3702aa32d41"

SRC_URI[sha256sum] = "8fc49a87ac269d4529da45871e2ffb6874e87779c3d0e2ccd813c0899221239d"

PYPI_PACKAGE = "aiohttp"

inherit pypi setuptools3
