SUMMARY = "Convert voluptuous schemas to dictionaries"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=dab31a1d28183826937f4b152143a33f"

SRC_URI[sha256sum] = "79acdc58239582a393144402d827fa8efd6df0f5350cdc606d9242f6f9bca7c4"

PYPI_PACKAGE = "voluptuous-serialize"

inherit pypi python_setuptools_build_meta setuptools3
