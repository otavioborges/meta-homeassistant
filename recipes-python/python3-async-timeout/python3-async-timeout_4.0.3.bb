SUMMARY = "Timeout context manager for asyncio programs"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=4fa41f15bb5f23b6d3560c5845eb8d57"

SRC_URI[sha256sum] = "4640d96be84d82d02ed59ea2b7105a0f7b33abe8703703cd0ab0bf87c427522f"

PYPI_PACKAGE = "async-timeout"

inherit pypi python_setuptools_build_meta setuptools3
