SUMMARY = "GitPython is a Python library used to interact with Git repositories"
HOMEPAGE = "https://github.com/gitpython-developers/GitPython"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=18130810ab035d8cac1d00602892f13d"

SRC_URI[sha256sum] = "01d9b76db3535374d720a06f5d66031f74e609698f0382fdd6ab3a0351210b72"

PYPI_PACKAGE = "isal"
inherit python_setuptools_build_meta pypi

