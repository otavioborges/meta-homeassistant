SUMMARY = "The most basic Text::Unidecode port"
HOMEPAGE = "https://github.com/kmike/text-unidecode/"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=ccfb8875bc60bc3d6e91e42e5e8f5587"

SRC_URI[sha256sum] = "bad6603bb14d279193107714b288be206cac565dfa49aa5b105294dd5c4aab93"

PYPI_PACKAGE = "text-unidecode"
inherit python_setuptools_build_meta pypi


