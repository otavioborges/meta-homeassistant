SUMMARY = "CPE: Common Platform Enumeration for Python"
HOMEPAGE = "https://github.com/nilp0inter/cpe"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=e6a600fd5e1d9cbde2d983680233ad02"

SRC_URI[sha256sum] = "e742635e13cc0f6e02cb62a367dc789fb0e7dba1317822a8760c8de312e36ec9"

PYPI_PACKAGE = "cpe"
inherit python_setuptools_build_meta pypi

