SUMMARY = "GitPython is a Python library used to interact with Git repositories"
HOMEPAGE = "https://github.com/gitpython-developers/GitPython"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=ae57d8a09fc8b6b164d7357339619045"

SRC_URI[sha256sum] = "b77827a689905143f87915310b93b273ab17888fd43ef350d4832c4a71083c13"

PYPI_PACKAGE = "brotlicffi"
inherit python_setuptools_build_meta pypi

