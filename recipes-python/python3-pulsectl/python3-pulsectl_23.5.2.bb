SUMMARY = "Python high-level interface and ctypes-based bindings for PulseAudio (libpulse)"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://README.rst;md5=21cbd21e6e1fcafb975a3d59cc322fbb"

SRC_URI[sha256sum] = "e911d398eaf0539cf3c63b4217357b51a3d1b7e4a50607d1591cf2b49f5d2c6a"

PYPI_PACKAGE = "pulsectl"

inherit pypi setuptools3
